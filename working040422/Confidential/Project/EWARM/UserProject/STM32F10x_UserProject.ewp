# IAR project STM32F10x_UserProject.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RD ST STM32F103RD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM32100B_EVAL; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM32100B_EVAL; ..\..\..\MCLibrary\interface\; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\SW048-SpiritDriverModule\inc; ..\..\..\SW054-CommonUtilitesModule\inc; ..\..\..\SW055-CM2CoreModule\inc; ..\..\..\SW097-AvengersCoreModule\inc; ..\..\..\SW098 TestAndProduction; ..\..\..\SW097-AvengersCoreModule\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..; ..\..\..\SW048-SpiritDriverModule\inc; ..\..\..\SW054-CommonUtilitesModule\inc; ..\..\..\SW055-CM2CoreModule\inc; ..\..\..\SW098 TestAndProduction; ..\..\..\SW097-AvengersCoreModule\inc
  OBJCOPY.OOCOutputFile: sw053 Avenger-xx_xx.bin
  ILINK.IlinkOutputFile: STM32F10x_UserProject.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210E-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM3210E_EVAL; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\; ..\..\..\PFC_Application\inc\
  ICCARM.CCOptLevel: 3
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210B_EVAL; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STM3210B_EVAL; ..\..\..\MCLibrary\interface\; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\; ..\..\..\PFC_Application\inc\; ..\..\..\SW054-CommonUtilitesModule\inc; ..\..\..\SW048-SpiritDriverModule\inc; ..\..\..\SW055-CM2CoreModule\inc
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: SW053-xx_xx.bin
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xD.icf
configuration STEVAL-IHM022V1_SINGLEDRIVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STEVAL_IHM022V1; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Common\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Common\Libraries\STM32_EVAL; ..\..\..\..\Common\Libraries\STM32_EVAL\Common; ..\..\..\..\Common\Libraries\STM32_EVAL\STEVAL-IHM022V1; ..\..\..\MCLibrary\interface\common\; ..\..\..\MCLibrary\interface\; ..\..\..\MCApplication\interface\; ..\..\..\MCApplication\inc\; ..\..\..\SystemDriveParams\; ..\..\..\UILibrary\interface\; ..\..\..\UILibrary\inc\; ..\..\..\PFC_Application\interface\; ..\..\..\PFC_Application\inc\
  ICCARM.CCOptLevel: 3
configuration STEVAL-IHM022V1_DUALDRIVE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../: readme.txt
    ../../: stm32f103xD.icf
  group Application
    ../../: appMotorRamp.c beep.c config.c driverButtonPsuedo.c driverFlash.c driverMagSensor.c main.c motor.c motor_braking.c new_beep.c SDK_EVAL_Spirit_Spi_Driver.c spiritInterface.c stm32f10x_it.c Timebase.c UITask.c
    ../../../SW098 TestAndProduction/: appProductionInfo.c appTestSupport.c
    ../../../SystemDriveParams/: stm32f10x_MC_it.c stm32f10x_MC_it_original.c
  group CM2Module
    ../../../SW055-CM2CoreModule/src/: CM2CoreSource.c CM2CoreTypesSource.c CM2FirmwareUpdateSource.c CM2PairingTableModeSource.c CM2PortsSource.c CM2RangeTestSource.c CM2RoutingSource.c CM2SecuritySource.c
  group CommonModule
    ../../../SW054-CommonUtilitesModule/src/: CommonUISource.c RandomSource.c RawCircularBufferSource.c ThreadingSource.c TimersSource.c
  group Motor control/MC Application/interface
    ../../../MCApplication/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group Motor control/MC Application/private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group Motor control/MC Application/src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group Motor control/MC Library/interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group Motor control/MC Library/interface/common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group Motor control/MC Library/lib
    ../MC Library Compiled/Exe/: MC_Library_STM32F10x_dual_drive.a MC_Library_STM32F10x_single_drive.a
  group Motor control/System & Drive Params
    ../../../SystemDriveParams/: Parameters conversion_F10X motor 2.h Parameters conversion_F10X.h SystemNDriveParams.h
  group Motor control/System & Drive Params/Motor1
    ../../../SystemDriveParams/: Control stage parameters.h Drive parameters.h Parameters conversion.h PMSM motor parameters.h Power stage parameters.h
  group Motor control/System & Drive Params/Motor2
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
  group SpiritDriver
    ../../../SW048-SpiritDriverModule/src/: JL_SpiritDriver.c SpiritTx.c
  group Std project template/CMSIS
    ../../../../Common/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Std project template/Doc
    ./: readme.txt
  group Std project template/EWARMv5
    ../../../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Std project template/StdPeriph_Driver
    ../../../../Common/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Std project template/STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../../Common/Libraries/STM32_EVAL/: stm32_eval.c
  group User interface/UI Library/interface
    ../../../UILibrary/interface/: DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h LCDVintage_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h UnidirectionalFastCom_UserInterfaceClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group User interface/UI Library/private
    ../../../UILibrary/inc/: DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCDManager_UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h UnidirectionalFastCom_UserInterfacePrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group User interface/UI Library/src
    ../../../UILibrary/src/: DAC_UserInterfaceClass.c DACRCTIMER_UserInterfaceClass.c DACSPI_UserInterfaceClass.c DACSPIAD7303_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UnidirectionalFastCom_UserInterfaceClass.c USART_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
