# Keil uVision project STM32F0xx_MC Library.uvprojx, settings and files
target STM32F0xx_SINGLE_DRIVE (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MC_Library_STM32F0xx_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,MC_LIBRARY_SINGLE
  c include: .\..\;".\..\..\MCLibrary";".\..\..\MCLibrary\inc";".\..\..\MCLibrary\interface";".\..\..\MCLibrary\interface\common";.\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F0xx\Include\;.\..\..\..\Common\Libraries\STM32F0xx_StdPeriph_Driver\inc\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MCLibrary_interface_common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h RampExtMngrClass.h
  group MCLibrary_interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_F0XX_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputClass_F30XPrivate.h DigitalOutputPrivate.h ENC_F0xx_SpeednPosFdbkPrivate.h ENC_F2xx_SpeednPosFdbkPrivate.h ENC_F4xx_SpeednPosFdbkPrivate.h ENC_F30X_SpeednPosFdbkPrivate.h EncAlignCtrlPrivate.h ENCODER_SpeednPosFdbkPrivate.h HALL_F0xx_SpeednPosFdbkPrivate.h HALL_F2xx_SpeednPosFdbkPrivate.h HALL_F4xx_SpeednPosFdbkPrivate.h HALL_F30X_SpeednPosFdbkPrivate.h HALL_SpeednPosFdbkPrivate.h ICS_F2XX_PWMnCurrFdbkPrivate.h ICS_F4XX_PWMnCurrFdbkPrivate.h ICS_F30X_PWMnCurrFdbkPrivate.h ICS_HD2_PWMnCurrFdbkPrivate.h ICS_LM1_PWMnCurrFdbkPrivate.h InrushCurrentLimiterPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h NTC_F30X_TemperatureSensorPrivate.h NTC_TemperatureSensorPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h R1_F0XX_PWMnCurrFdbkPrivate.h R1_F2XX_PWMnCurrFdbkPrivate.h R1_F4XX_PWMnCurrFdbkPrivate.h R1_F30X_PWMnCurrFdbkPrivate.h R1_HD2_PWMnCurrFdbkPrivate.h R1_LM1_PWMnCurrFdbkPrivate.h R1_VL1_PWMnCurrFdbkPrivate.h R3_2_F30X_PWMnCurrFdbkPrivate.h R3_4_F30X_PWMnCurrFdbkPrivate.h R3_F2XX_PWMnCurrFdbkPrivate.h R3_F4XX_PWMnCurrFdbkPrivate.h R3_HD2_PWMnCurrFdbkPrivate.h R3_LM1_PWMnCurrFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h Rdivider_BusVoltageSensorPrivate.h Rdivider_F30X_BusVoltageSensorPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h CircleLimitationPrivate.h OpenLoopPrivate.h
  group MCLibrary_src
    ../../MCLibrary/src/: BusVoltageSensorClass.c DigitalOutputClass_F0XX.c ENC_F0xx_SpeednPosFdbkClass.c EncAlignCtrlClass.c HALL_F0xx_SpeednPosFdbkClass.c InrushCurrentLimiterClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c NTC_F0XX_TemperatureSensorClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c R1_F0XX_PWMnCurrFdbkClass.c RampMngrClass.c RampExtMngrClass.c Rdivider_F0XX_BusVoltageSensorClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c CircleLimitationClass.c OpenLoopClass.c
  group MCLibrary_lib
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_SINGLE/: MC_Library_ProtectedSources_single_drive_CM0_MKD.lib
  group MCLibrary_conf
    ../../MCLibrary/: stm32f0xx_MisraCompliance.h MCLibraryConf.h
