# IAR project Spirit Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: inc; ..\SW054-CommonUtilitesModule\inc; ..\SW055-CM2CoreModule\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Spirit Module.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 1
configuration Debug M4 (ARM, debug)
  as the first configuration, except:
  group Include
    inc/: JL_SpiritDriver.h MCU_Interface.h SPIRIT_Commands.h SPIRIT_Irq.h SPIRIT_Regs.h SPIRIT_Types.h SpiritErrataHeader.h SpiritModuleInterface.h
  group Source
    src/: JL_SpiritDriver.c SpiritErrataSource.c
