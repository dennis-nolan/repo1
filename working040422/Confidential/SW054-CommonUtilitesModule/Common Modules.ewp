# IAR project Common Modules.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Common Modules.out
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
configuration UT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; TRACK_MEM_USED
  ICCARM.PreInclude: ..\cpputest\include\CppUTest\MemoryLeakDetectorMallocMacros.h
  ICCARM.CCIncludePath2: inc; ..\cpputest\include; UT\UT Support
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkIcfFile: UnitTest.icf
  ILINK.IlinkAdditionalLibs: ..\cpputest\Cortex-M0-build\cpputest_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UT Lib (ARM, debug)
  as the first configuration, except:
  ICCARM.PreInclude: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkIcfFile: C:\Users\bhiggins\Desktop\Common Modules\UnitTest.icf
  ILINK.IlinkAdditionalLibs: C:\Users\bhiggins\Desktop\SPIRIT1 Radio Dev\DevelopmentSpirit\Brad's updates\cpputest\Debug\cpputest_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug M4 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  group inc
    inc/: commonTypes.h CommonUIHeader.h RawCircularBufferHeader.h ThreadingHeader.h TimersHeader.h
  group src
    src/: CommonUISource.c RawCircularBufferSource.c ThreadingSource.c TimersSource.c
  group UT
    UT/: AllTests.cpp CircularBufferTest.cpp CommonUITest_Buttons.cpp CommonUITest_Leds.cpp MemoryMgmtTest.cpp RawCircularBufferTest.cpp ThreadingTest.cpp TimersTest.cpp
  group UT Support
    UT/UT Support/: CallbackTestHelper.c CallbackTestHelper.h UIMocks.c UIMocks.h
