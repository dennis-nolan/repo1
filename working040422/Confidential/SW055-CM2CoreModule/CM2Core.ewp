# IAR project CM2Core.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\SW054-CommonUtilitesModule\inc; inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CM2Core.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc; ..\SW054-CommonUtilitesModule\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UT (ARM, debug)
  as the first configuration, except:
  ICCARM.PreInclude: ..\cpputest\include\CppUTest\MemoryLeakDetectorMallocMacros.h
  ICCARM.CCIncludePath2: ..\SW054-CommonUtilitesModule\inc; inc; ..\cpputest\include; UT; ..\cpputest\include\CppUTest
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CM2Core.srec
  ILINK.IlinkIcfFile: UnitTest.icf
  ILINK.IlinkExtraOptions: LD_LIBRARIES = -L$"C:\Users\bhiggins\Desktop\SPIRIT1 Radio Dev\DevelopmentSpirit\Brad's updates\cpputest\lib" -lCppUTest
  ILINK.IlinkAdditionalLibs: ..\cpputest\Cortex-M0-build\cpputest_lib.a; ..\SW054-CommonUtilitesModule\UT Lib\Exe\Common Modules.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UT Lib (ARM, debug)
  as the first configuration, except:
  ICCARM.PreInclude: as above
  ICCARM.CCIncludePath2: ..\SW046-CommonUtilitesModule\inc; inc; ..\cpputest\include; UT; ..\cpputest\include\CppUTest
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CM2Core.srec
  ILINK.IlinkIcfFile: UnitTest.icf
  ILINK.IlinkExtraOptions: as above
  ILINK.IlinkAdditionalLibs: ..\cpputest\Cortex-M0-build\cpputest_lib.a; ..\SW046-CommonUtilitesModule\UT Lib\Exe\Common Modules.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug M4 (ARM, debug)
  as the first configuration, except:
  group Include
    inc/: CM2CoreHeader.h CM2CoreTypesHeader.h CM2DiagnosticsHeader.h CM2FirmwareUpdateHeader.h CM2NetworkModeHeader.h CM2PairingTableModeHeader.h CM2PortsHeader.h CM2RangeTestHeader.h CM2RoutingHeader.h CM2SecurityHeader.h
  group Source
    src/: CM2CoreSource.c CM2CoreTypesSource.c CM2DiagnosticsSource.c CM2FirmwareUpdateSource.c CM2NetworkModeSource.c CM2PairingTableModeSource.c CM2PortsSource.c CM2RangeTestSource.c CM2RoutingSource.c CM2SecuritySource.c
  group UT
    UT/: AllTests.cpp CM2RoutingMocks.c CM2UTMocks.c CM2UTUtils.c CoreTypesTest.cpp DiagnosticsTest.cpp ExtendedPacketTest.cpp FlashMocks.c NetworkingPacketTest.cpp PairingTest.cpp RoutingTest.cpp SecurityTest.cpp
